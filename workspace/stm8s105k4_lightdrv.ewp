# IAR project stm8s105k4_lightdrv.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; USE_STDPERIPH_DRIVER
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ..\; ..\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group LIB
    ../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group User
    ../: LightPwmDrv.c main.c ProtocolParser.c rf24l01.c stm8s_it.c Uart2Dev.c Uart2Dev.h
